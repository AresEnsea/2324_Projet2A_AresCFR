# IAR project stm32f746_disco_lvgl.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32; STM32F7; STM32F746NGHx; STM32F746G_DISCO; DEBUG; STM32F746xx; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa089,Pe188
  ICCARM.CCIncludePath2: ../..; ../../CMSIS/Core; ../../CMSIS/device; ../../HAL_Driver/Inc; ../../Utilities/STM32746G-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; STM32; STM32F7; STM32F746NGHx; STM32F746G_DISCO; DEBUG; STM32F746xx; USE_HAL_DRIVER
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: stm32f746_disco_lvgl.hex
  group HAL_Driver/Src
    ../../HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_mmc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_smbus.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_timebase_rtc_alarm_template.c stm32f7xx_hal_timebase_rtc_wakeup_template.c stm32f7xx_hal_timebase_tim_template.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_adc.c stm32f7xx_ll_crc.c stm32f7xx_ll_dac.c stm32f7xx_ll_dma.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_exti.c stm32f7xx_ll_fmc.c stm32f7xx_ll_gpio.c stm32f7xx_ll_i2c.c stm32f7xx_ll_lptim.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_rng.c stm32f7xx_ll_rtc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_spi.c stm32f7xx_ll_tim.c stm32f7xx_ll_usart.c stm32f7xx_ll_usb.c stm32f7xx_ll_utils.c
  group hal_stm_lvgl/tft
    ../../hal_stm_lvgl/tft/: tft.c
  group hal_stm_lvgl/touchpad
    ../../hal_stm_lvgl/touchpad/: touchpad.c
  group lv_examples/assets
    ../../lvgl/examples/assets/: animimg001.c animimg002.c animimg003.c img_caret_down.c img_cogwheel_alpha16.c img_cogwheel_argb.c img_cogwheel_chroma_keyed.c img_cogwheel_indexed16.c img_cogwheel_rgb.c img_hand.c img_skew_strip.c img_star.c imgbtn_left.c imgbtn_mid.c imgbtn_right.c
  group lv_examples/src/lv_demo_benchmark
    ../../lvgl/demos/benchmark/: lv_demo_benchmark.c
  group lv_examples/src/lv_demo_benchmark/assets
    ../../lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
  group lv_examples/src/lv_demo_keypad_encoder
    ../../lvgl/demos/keypad_encoder/: lv_demo_keypad_encoder.c
  group lv_examples/src/lv_demo_music
    ../../lvgl/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
  group lv_examples/src/lv_demo_music/assets
    ../../lvgl/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
  group lv_examples/src/lv_demo_stress
    ../../lvgl/demos/stress/: lv_demo_stress.c
  group lv_examples/src/lv_demo_stress/assets
    ../../lvgl/demos/stress/assets/: lv_font_montserrat_12_compr_az.c lv_font_montserrat_16_compr_az.c lv_font_montserrat_28_compr_az.c
  group lv_examples/src/lv_demo_widgets
    ../../lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
    ../../lvgl/demos/widgets/: lv_demo_widgets.c
  group lvgl/src/core
    ../../lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl/src/draw
    ../../lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lvgl/src/draw/stm32_dma2d
    ../../lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group lvgl/src/draw/sw
    ../../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group lvgl/src/extra
    ../../lvgl/src/extra/: lv_extra.c
  group lvgl/src/extra/layouts/flex
    ../../lvgl/src/extra/layouts/flex/: lv_flex.c
  group lvgl/src/extra/layouts/grid
    ../../lvgl/src/extra/layouts/grid/: lv_grid.c
  group lvgl/src/extra/others/snapshot
    ../../lvgl/src/extra/others/snapshot/: lv_snapshot.c
  group lvgl/src/extra/themes/basic
    ../../lvgl/src/extra/themes/basic/: lv_theme_basic.c
  group lvgl/src/extra/themes/default
    ../../lvgl/src/extra/themes/default/: lv_theme_default.c
  group lvgl/src/extra/themes/mono
    ../../lvgl/src/extra/themes/mono/: lv_theme_mono.c
  group lvgl/src/extra/widgets/animimg
    ../../lvgl/src/extra/widgets/animimg/: lv_animimg.c
  group lvgl/src/extra/widgets/calendar
    ../../lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
  group lvgl/src/extra/widgets/chart
    ../../lvgl/src/extra/widgets/chart/: lv_chart.c
  group lvgl/src/extra/widgets/colorwheel
    ../../lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
  group lvgl/src/extra/widgets/imgbtn
    ../../lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
  group lvgl/src/extra/widgets/keyboard
    ../../lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
  group lvgl/src/extra/widgets/led
    ../../lvgl/src/extra/widgets/led/: lv_led.c
  group lvgl/src/extra/widgets/list
    ../../lvgl/src/extra/widgets/list/: lv_list.c
  group lvgl/src/extra/widgets/menu
    ../../lvgl/src/extra/widgets/menu/: lv_menu.c
  group lvgl/src/extra/widgets/meter
    ../../lvgl/src/extra/widgets/meter/: lv_meter.c
  group lvgl/src/extra/widgets/msgbox
    ../../lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
  group lvgl/src/extra/widgets/span
    ../../lvgl/src/extra/widgets/span/: lv_span.c
  group lvgl/src/extra/widgets/spinbox
    ../../lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
  group lvgl/src/extra/widgets/spinner
    ../../lvgl/src/extra/widgets/spinner/: lv_spinner.c
  group lvgl/src/extra/widgets/tabview
    ../../lvgl/src/extra/widgets/tabview/: lv_tabview.c
  group lvgl/src/extra/widgets/tileview
    ../../lvgl/src/extra/widgets/tileview/: lv_tileview.c
  group lvgl/src/extra/widgets/win
    ../../lvgl/src/extra/widgets/win/: lv_win.c
  group lvgl/src/font
    ../../lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group lvgl/src/hal
    ../../lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/src/misc
    ../../lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/src/widgets
    ../../lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group src
    ../../src/: main.c stm32f7xx_it.c system_stm32f7xx.c
  group startup
    ./: startup_stm32f746xx.s
  group Utilities/Components/ft5336
    ../../Utilities/Components/ft5336/: ft5336.c
  group Utilities/STM32746G-Discovery
    ../../Utilities/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_audio.c stm32746g_discovery_camera.c stm32746g_discovery_eeprom.c stm32746g_discovery_qspi.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
